options:
  parameters:
    author: Philippe PUJAS
    generate_options: qt_gui
    id: Test_audio
    output_language: python
    title: Test audio, MUC/DMUX Rx21
  states: {}

blocks:
- name: fe_wav
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: fe_wav
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bastien/But-1ere-annee/R300/R321/01-960k.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: float
    ymax: '0'
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fe_wav
    fc: '0'
    fftsize: '2048'
    type: float
    ymax: '0'
    ymin: '-150'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/fe_wav)
    interp: '1'
    type: fff
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
