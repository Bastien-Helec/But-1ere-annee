options:
  parameters:
    author: Philippe PUJAS
    generate_options: qt_gui
    id: TP3_FDM_MUX
    output_language: python
    title: Multiplexeur fréquence Rx21
  states: {}

blocks:
- name: BP
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: canal_a_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ch0
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: chsp
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: num_canal_A
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_canal_B
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_canal_C
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1920000/2
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch0+num_canal_A*chsp
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch0+num_canal_B*chsp
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch0+num_canal_C*chsp
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bastien/But-1ere-annee/R300/R321/04-960k.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bastien/But-1ere-annee/R300/R321/09-960k.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bastien/But-1ere-annee/R300/R321/12-960k.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: c1
    type: float
    wintype: window.WIN_FLATTOP
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: v1
    label2: v2
    label3: Mux
    nconnections: '3'
    type: float
    wintype: window.WIN_FLATTOP
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: v1
    label2: v2
    label3: Mux
    nconnections: '3'
    type: float
    wintype: window.WIN_FLATTOP
    ymin: '-150'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_1_0, '2']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_1_0, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_wavfile_source_0_0, '0', qtgui_freq_sink_x_0_1, '1']
- [blocks_wavfile_source_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_wavfile_source_0_0_0, '0', qtgui_freq_sink_x_0_1, '2']

metadata:
  file_format: 1
